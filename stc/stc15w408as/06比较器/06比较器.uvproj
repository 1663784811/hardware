# Keil uVision project 06比较器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 06比较器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c ADC.c ADC.h Soft_UART.c soft_uart.h config.h delay.c delay.h compare.c compare.h GPIO.c GPIO.h

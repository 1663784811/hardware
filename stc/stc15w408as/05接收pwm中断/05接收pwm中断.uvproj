# Keil uVision project 05接收pwm中断.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 05接收pwm中断 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 config.h delay.c delay.h Exti.c Exti.h main.c USART1.C USART1.h timer.c timer.h GPIO.c GPIO.h

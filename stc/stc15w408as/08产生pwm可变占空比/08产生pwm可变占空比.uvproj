# Keil uVision project 08产生pwm可变占空比.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 08产生pwm可变占空比 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 config.h delay.c delay.h Exti.c Exti.h GPIO.c GPIO.h main.c timer.c timer.h USART1.C USART1.h

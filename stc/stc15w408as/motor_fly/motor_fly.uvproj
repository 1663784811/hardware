# Keil uVision project motor_fly.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: motor_fly +hex
  c flags: Optimize=9 SizeSpeed=1
  group user
    ./: STARTUP.A51 config.h delay.c delay.h main.c USART1.C USART1.h timer.c timer.h GPIO.c GPIO.h ADC.c ADC.h compare.c compare.h

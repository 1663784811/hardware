# Keil uVision project 02定时器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 02定时器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: STARTUP.A51 main.c USART1.C USART1.h timer.h timer.c config.h delay.c delay.h GPIO.c GPIO.h

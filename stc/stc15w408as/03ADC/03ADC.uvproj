# Keil uVision project 03ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 03ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: STARTUP.A51 main.c config.h ADC.c ADC.h delay.c delay.h USART1.C USART1.h
